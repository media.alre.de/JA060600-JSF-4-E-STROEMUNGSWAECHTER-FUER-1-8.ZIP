Properties of the parts of a building model (IFC2X3)

# File
Description: Strömungswächter JSF für 3/4", ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: JA060600, Strömungswächter JSF für 3/4"
In: Raum
Description: Dieser Strömungswächter wurde speziell zur Überwachung der Strömung von flüssigen Medien entwickelt. Typischen Einsatz findet der Wächter im Maschinen- und Apparatebau, zur Überwachung von Öl-, Kühl- und Schmierkreisläufen oder als Wassermangelsicherung in Beregnungsanlagen, in Heizungsanlagen, Kaltwassersätzen und Wärmepumpen. Der Einbau erfolgt senkrecht in eine waagerechte Rohrleitung. Als Beruhigungsstrecke ist mindenstens der 5-fache Rohrdurchmesser vor und hinter dem Paddel vorzusehen. Die maximale Strömung kann wesentlich höher sein als der max. Einstellwert des Wächters. Nicht trinkwassergeprüft. Angebautes T-Stück aus Grauguss.; Classification: EC011194 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: JA060600; ModelLabel: JSF-4 E; GlobalTradeItemNumber: 4050528047137; ProductURL: https://alre.de/produkt_JA060600
Pset_Specification - NominalLength: 0.144 m; NominalWidth: 0.071 m; NominalDepth: 0.067 m; NetWeight: 0.992
Pset_ALRE_ETIM_Properties - Spannungsart: AC; Explosionsgeschützt: no; Schutzart (IP): IP65; Ausführung Aufnehmer/Fühler: Fahne; Max. Spannung der Kontakte: 230; Werkstoff des Prozessanschlusses: Messing; Geeignet für Medium: Flüssigstoffe; Material Wimpel: rostfreier Stahl; Max. Kontaktbelastung: 15; ETIM-Klasse: EC011194; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-JA060600.pdf
